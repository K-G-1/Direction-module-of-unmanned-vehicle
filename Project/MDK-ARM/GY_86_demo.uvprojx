# Keil uVision project GY_86_demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GY_86_demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F072
  c include: ..\..\Libraries\CMSIS\ST\STM32F0xx\Source\Templates\arm;..\..\Libraries\CMSIS\ST\STM32F0xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\BSP;..\MDK-ARM;..\..\Project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group CMSIS
    ../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group STD Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group BSP
    ../../BSP/: led.c i2c.c systick.c usart.c mpu6050.c IMU.c HMC5883L.c timer.c receivedata.c stmflash.c
  group USER
    ./: main.c
    ../: stm32f0xx_it.c
